# Keil uVision project BleRemoteCar.uvproj, settings and files
target BleRemoteCar (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: BleRemoteCar +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\Services;..\Libraries\Include;..\Libraries\Include\app_common;..\Libraries\Include\ble;..\Libraries\Include\ble\ble_services;..\Libraries\Include\s110;..\Libraries\Include\sd_common;D:\soft\Keil\ARM\PACK\ARM\CMSIS\4.5.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../Libraries/Source/templates/arm/: arm_startup_nrf51.s
    ../Libraries/Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: BleInit.c PotocolParser.c MotorDev.c
  group Services
    ../Services/: ble_nus.c
    ../Libraries/Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../Libraries/Source/ble/: ble_advdata.c ble_conn_params.c
    ../Libraries/Source/sd_common/: softdevice_handler.c
    ../Libraries/Source/simple_uart/: simple_uart.c
    ../Libraries/Source/app_common/: app_timer.c
  group ReadMe
    ../ReadMe/: ReadMe.txt
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_uart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
